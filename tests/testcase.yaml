## tests/testcase.yaml
```yaml
tests:
  main.testing.ztest:
    build_only: false
    tags: sample
    platform_allow:
      - native_posix
      - qemu_cortex_m3
```
